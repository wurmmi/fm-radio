options:
  parameters:
    author: Michael Wurm <wurm.michael95@gmail.com>
    copyright: (C) M. Wurm 2021
    description: FM Sender, using USRP.
    generate_options: qt_gui
    id: fm_transmitter
    output_language: python
    title: FM Sender
  states: {}

blocks:
- name: fc_pirate
  id: variable
  parameters:
    value: 99e6
  states: {}
- name: fs_file
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: fs_mod
  id: variable
  parameters:
    value: fs_file*osr_mod
  states: {}
- name: fs_rf
  id: variable
  parameters:
    value: fs_file*osr_mod*osr_rf
  states: {}
- name: gain_hinz
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: gain_hinz
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '0.5'
    value: '0.05'
  states: {}
- name: gain_lrdiff
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: gain_lrdiff
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.5'
  states: {}
- name: gain_mono
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: gain_mono
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.3'
  states: {}
- name: gain_pilot
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: gain_pilot
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.05'
  states: {}
- name: gain_rds
  id: variable_qtgui_range
  parameters:
    gui_hint: 8,0,1,1
    label: gain_rds
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.05'
  states: {}
- name: n_filter_delay
  id: variable_qtgui_range
  parameters:
    comment: |-
      #####
       (1) Find the code line, where the bp filter is constructed:

              self.band_pass_filter_0 = filter.fir_filter_fff(
                  1,
                  firdes.band_pass(
                      1,
                      fs_mod,
                      23e3,
                      53e3,
                      2e3,
                      firdes.WIN_HAMMING,
                      6.76))
      #####
      (2) Add the following lines, to find out the group delay:

              taps = firdes.band_pass(1, self.fs_mod, 23e3, 53e3, 2e3, firdes.WIN_HAMMING, 6.76)

              print("len(taps):  {}".format(len(taps)))
              print("groupdelay: {}".format((len(taps) - 1) / 2))
    gui_hint: 9,0,1,1
    label: n_filter_delay
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '400'
    value: 289//2
  states: {}
- name: osr_mod
  id: variable
  parameters:
    value: '5'
  states: {}
- name: osr_rf
  id: variable
  parameters:
    value: '4'
  states: {}
- name: outbuffer
  id: variable
  parameters:
    value: '10'
  states: {}
- name: tx_gain_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: tx_gain_db
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.8'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: fs_file
    tau: '50e-6'
  states: {}
- name: analog_fm_preemph_0_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: fs_file
    tau: '50e-6'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 75e3/fs_mod*2*math.pi
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: 38kHz Subcarrier
    freq: 38e3
    offset: '0'
    phase: '0'
    samp_rate: fs_mod
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: 19kHz Pilot Tone
    freq: 19e3
    offset: '0'
    phase: '0'
    samp_rate: fs_mod
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: fs_mod
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: fs_mod
    tau: '50e-6'
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: |-
      Checkout this link.
      https://wiki.gnuradio.org/index.php/ALSAPulseAudio
    device_name: pulse_monitor
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_source_0_0
  id: audio_source
  parameters:
    comment: |-
      Checkout this link.
      https://wiki.gnuradio.org/index.php/ALSAPulseAudio
    device_name: pulse_monitor
    num_outputs: '2'
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    alias: filter_bp_lrdiff
    decim: '1'
    gain: '1'
    high_cutoff_freq: 53e3
    low_cutoff_freq: 23e3
    samp_rate: fs_mod
    type: fir_filter_fff
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 15e3
    low_cutoff_freq: '30'
    samp_rate: fs_mod
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_1_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 15e3
    low_cutoff_freq: '30'
    samp_rate: fs_mod
    type: fir_filter_fff
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: mono
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: Compensate BP Filter.
    delay: n_filter_delay
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    comment: Compensate BP Filter.
    delay: n_filter_delay
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_rds
    maxoutbuf: outbuffer
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    comment: gain_mono
    const: gain_mono
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    comment: gain_lrdiff
    const: gain_lrdiff
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0_0
  id: blocks_multiply_const_xx
  parameters:
    comment: gain_pilot
    const: gain_pilot
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_2
  id: blocks_multiply_const_xx
  parameters:
    comment: gain_mono
    const: gain_hinz
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(fs_mod/2.375/1000)
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: LRDiff
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ../matlab/recordings/wav/left-right-mix-viera-blech-ehrenwert-polka_48000.wav
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: goto_pwd_module
  id: epy_module
  parameters:
    source_code: |
      # -------------------------------------------------------------------------
      # File:        generateHinzTrillerFile.m
      # Author:      Michael Wurm < wurm.michael95 @ gmail.com >
      # Description: Stores the Hinz Triller in an audio file(*.wav).
      # -------------------------------------------------------------------------

      import os

      script_path = os.path.dirname(os.path.realpath(__file__))
      os.chdir(script_path)
  states: {}
- name: gr_char_to_float_0
  id: blocks_char_to_float
  parameters:
    maxoutbuf: outbuffer
    scale: '1'
  states: {}
- name: gr_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    maxoutbuf: outbuffer
    modulus: '2'
  states: {}
- name: gr_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1,1]'
    maxoutbuf: outbuffer
  states: {}
- name: gr_map_bb_1
  id: digital_map_bb
  parameters:
    map: '[1,2]'
    maxoutbuf: outbuffer
  states: {}
- name: gr_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    maxoutbuf: outbuffer
    type: float
  states: {}
- name: gr_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 57e3
    offset: '0'
    phase: '0'
    samp_rate: fs_mod
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: gr_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
    maxoutbuf: outbuffer
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2.5e3
    gain: '1'
    interp: '1'
    maxoutbuf: outbuffer
    samp_rate: fs_mod
    type: interp_fir_filter_fff
    width: .5e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: fs_mod
    fc: '0'
    fftsize: 4096*2
    freqhalf: 'False'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@0
    name: '"fmChannelData"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: fs_mod
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@1
    name: '"tx_fm_bb"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: fs_rf
    fc: fc_pirate
    fftsize: '8092'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@2
    name: '"tx_fm_mod"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 5,0,1,1
    label0: Tab 0
    label1: Tab 1
    label2: Tab 2
    num_tabs: '3'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: osr_rf
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: osr_mod
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: osr_mod
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: osr_mod
    taps: ''
    type: fff
  states: {}
- name: rds_encoder_0
  id: rds_encoder
  parameters:
    af1: 47.11e6
    ms: 'True'
    pi_country_code: '13'
    pi_coverage_area: '3'
    pi_reference_number: '147'
    ps: PIRAT 17
    pty: '20'
    pty_locale: '0'
    radiotext: SAALFELDEN TESTING
    ta: 'False'
    tp: 'True'
  states: {}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: 200e3
    center_freq0: fc_pirate
    dev_args: '""'
    gain0: tx_gain_db
    len_tag_name: ''
    norm_gain0: 'True'
    samp_rate: fs_rf
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: audioMono
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: audioLRDiff
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: fmChannelData
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: audioMono
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: audioLRDiff
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: fmChannelData
  states: {}

connections:
- [analog_const_source_x_0, '0', rational_resampler_xxx_0_0_0_0, '0']
- [analog_fm_preemph_0, '0', blocks_add_xx_0, '0']
- [analog_fm_preemph_0, '0', blocks_sub_xx_0, '0']
- [analog_fm_preemph_0_0, '0', blocks_add_xx_0, '1']
- [analog_fm_preemph_0_0, '0', blocks_sub_xx_0, '1']
- [analog_frequency_modulator_fc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_frequency_modulator_fc_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_delay_0, '0']
- [analog_wfm_tx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '0', rational_resampler_xxx_0_0_0_0, '0']
- [audio_source_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0_0, '1', blocks_multiply_const_vxx_0_1, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_xx_0_0, '0']
- [band_pass_filter_1, '0', virtual_sink_0, '0']
- [band_pass_filter_1_0, '0', virtual_sink_1, '0']
- [blocks_add_xx_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_add_xx_0_0, '0', virtual_sink_2, '0']
- [blocks_delay_0, '0', blocks_multiply_const_xx_0_0_0, '0']
- [blocks_delay_0_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_fm_preemph_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0_0, '4']
- [blocks_multiply_const_vxx_0_1, '0', analog_fm_preemph_0_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_add_xx_0_0, '0']
- [blocks_multiply_const_xx_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_xx_0_0_0, '0', blocks_add_xx_0_0, '2']
- [blocks_multiply_const_xx_0_2, '0', blocks_add_xx_0_0, '3']
- [blocks_multiply_xx_0, '0', band_pass_filter_0, '0']
- [blocks_repeat_0, '0', low_pass_filter_0, '0']
- [blocks_sub_xx_0, '0', rational_resampler_xxx_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_wavfile_source_0, '1', blocks_multiply_const_vxx_0_1, '0']
- [gr_char_to_float_0, '0', blocks_repeat_0, '0']
- [gr_diff_encoder_bb_0, '0', gr_map_bb_1, '0']
- [gr_map_bb_0, '0', gr_char_to_float_0, '0']
- [gr_map_bb_1, '0', gr_unpack_k_bits_bb_0, '0']
- [gr_multiply_xx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [gr_sig_source_x_0_0, '0', gr_multiply_xx_0, '0']
- [gr_unpack_k_bits_bb_0, '0', gr_map_bb_0, '0']
- [low_pass_filter_0, '0', gr_multiply_xx_0, '1']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_1, '0']
- [rational_resampler_xxx_0_0, '0', band_pass_filter_1, '0']
- [rational_resampler_xxx_0_0_0, '0', band_pass_filter_1_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', blocks_multiply_const_xx_0_2, '0']
- [rds_encoder_0, '0', gr_diff_encoder_bb_0, '0']
- [virtual_source_0, '0', blocks_delay_0_0, '0']
- [virtual_source_1, '0', blocks_multiply_xx_0, '0']
- [virtual_source_2, '0', analog_frequency_modulator_fc_0, '0']
- [virtual_source_2, '0', analog_wfm_tx_0, '0']
- [virtual_source_2, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
