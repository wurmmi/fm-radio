options:
  parameters:
    author: Michael Wurm
    generate_options: qt_gui
    id: audio_source_test
    output_language: python
    title: Audio Source Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 44.1e3
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: |-
      Checkout this link.
      https://wiki.gnuradio.org/index.php/ALSAPulseAudio
    device_name: pulse_monitor
    ok_to_block: 'False'
    samp_rate: '44100'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [audio_source_0, '0', qtgui_freq_sink_x_0, '0']
- [audio_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
