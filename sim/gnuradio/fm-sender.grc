options:
  parameters:
    author: Michael Wurm <wurm.michael95@gmail.com>
    description: FM Sender, using USRP.
    generate_options: qt_gui
    id: fm_sender
    output_language: python
    title: FM Sender
  states: {}

blocks:
- name: fc_pirate
  id: variable
  parameters:
    value: 92.3e6
  states: {}
- name: fs_file
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: fs_mod
  id: variable
  parameters:
    value: fs_file*osr_mod
  states: {}
- name: osr_mod
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: fc_pirate
    offset: '0'
    phase: '0'
    samp_rate: fs_mod
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: fs_file
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: fs_mod
    tau: '50e-6'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/mike/work/fm-radio/sim/matlab/recordings/left-right-test.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: fs_file
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    name: '"audioMono"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: fs_file
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    name: '"tx_fm"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: fs_mod
    fc: '0'
    fftsize: '8092'
    grid: 'True'
    name: '"tx_fm_mod"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: fc_pirate
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: fs_mod
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: '0'
    clock_rate: 200e6
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: fs_mod
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_tx_0, '0', blocks_multiply_xx_0, '0']
- [analog_wfm_tx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', analog_wfm_tx_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_1, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_wavfile_source_0, '1', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
