options:
  parameters:
    author: Michael Wurm <wurm.michael95@gmail.com>
    description: FM Sender, using USRP.
    generate_options: qt_gui
    id: fm_sender
    output_language: python
    title: FM Sender
  states: {}

blocks:
- name: fc_pirate
  id: variable
  parameters:
    value: 99e6
  states: {}
- name: fs_file
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: fs_mod
  id: variable
  parameters:
    value: fs_file*osr_mod
  states: {}
- name: fs_rf
  id: variable
  parameters:
    value: fs_file*osr_mod*osr_rf
  states: {}
- name: gain_lrdiff
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: gain_lrdiff
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.45'
  states: {}
- name: gain_mono
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: gain_mono
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.45'
  states: {}
- name: gain_pilot
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: gain_pilot
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.1'
  states: {}
- name: osr_mod
  id: variable
  parameters:
    value: '20'
  states: {}
- name: osr_rf
  id: variable
  parameters:
    value: '3'
  states: {}
- name: tx_gain_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: tx_gain_db
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '120'
    value: '50'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.2'
    comment: 38kHz Subcarrier
    freq: 38e3
    offset: '0'
    phase: '0'
    samp_rate: fs_mod
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.05'
    comment: 19kHz Pilot Tone
    freq: 19e3
    offset: '0'
    phase: '0'
    samp_rate: fs_mod
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: fs_mod
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: fs_mod
    tau: '50e-6'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: mono
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: gain_mono
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: gain_lrdiff
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: gain_pilot
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_1
  id: blocks_multiply_const_xx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_1_0
  id: blocks_multiply_const_xx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: LRDiff
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/mike/work/fm-radio/sim/matlab/recordings/left-right-test.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: fs_mod
    fc: '0'
    fftsize: 4096*2
    freqhalf: 'False'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@0
    name: '"fmChannelData"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: fs_mod
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@1
    name: '"tx_fm_bb"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: fs_rf
    fc: fc_pirate
    fftsize: '8092'
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@2
    name: '"tx_fm_mod"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 4,0,1,1
    label0: Tab 0
    label1: Tab 1
    label2: Tab 2
    num_tabs: '3'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: osr_rf
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: left
    decim: '1'
    interp: osr_mod
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    comment: right
    decim: '1'
    interp: osr_mod
    taps: ''
    type: fff
  states: {}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: 300e3
    center_freq0: fc_pirate
    dev_args: '""'
    gain0: tx_gain_db
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: fs_rf
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_const_xx_0_0_0, '0']
- [analog_wfm_tx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_add_xx_0_0, '0', analog_wfm_tx_0, '0']
- [blocks_add_xx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_add_xx_0_0, '0']
- [blocks_multiply_const_xx_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_xx_0_0_0, '0', blocks_add_xx_0_0, '2']
- [blocks_multiply_const_xx_0_1, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_const_xx_0_1_0, '0', rational_resampler_xxx_0_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_xx_0_1, '0']
- [blocks_wavfile_source_0, '1', blocks_multiply_const_xx_0_1_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [rational_resampler_xxx_0, '0', uhd_usrp_sink_1, '0']
- [rational_resampler_xxx_0_0, '0', blocks_add_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_sub_xx_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_add_xx_0, '1']
- [rational_resampler_xxx_0_0_0, '0', blocks_sub_xx_0, '1']

metadata:
  file_format: 1
